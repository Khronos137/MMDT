Commit message: Hasta 10-02-2023

File: src/mmdt_rat20/urdf/mmdt_rat20.urdf (robot description, URDF)
Before this commit: robot mmdt_rat20, 22 links, 21 joints
Links:
- link chasis: mass 360.428 -> 30.428
